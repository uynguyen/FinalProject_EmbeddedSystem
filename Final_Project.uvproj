# Keil uVision project Final_Project.uvproj, settings and files
target 1212505_1212513 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Final_Project
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\CMSIS\Include;.\Include;.\Audio\inc;.\Audio\STM32F4-Discovery
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group StartUp
    ./: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group Source
    ./Source/: main.c
  group MyModules
    ./Source/: LED.c SPI.c Uart.c SimpleLED.c Operation.c audio.c MyStack.c linked_list.c
    ./: AdvanceLED.c
  group CMSISModules
    ./CMSIS/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_i2c.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c
  group STM32F4-Discovery
    ./Audio/STM32F4-Discovery/: stm32f4_discovery.c stm32f4_discovery_audio_codec.c stm32f4_discovery_lis302dl.c
  group AudioModule
    ./Audio/src/: waveplayer.c
    ./AudioFiles/: audio_sample.c
